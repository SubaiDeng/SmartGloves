# Keil uVision project SmartGlove.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SmartGlove +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Library\inc;..\Library\src;..\User;..\Library\CMSIS;..\Driver\MPU6050;..\Driver\LED;..\Driver\Usart;..\Driver\DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../Library/CMSIS/StartUp/: startup_stm32f10x_cl.s
  group Driver
    ../Driver/MPU6050/: MPU6050.c
    ../Driver/LED/: led.c
    ../Driver/Usart/: bsp_usart.c
    ../Driver/DMA/: bsp_DMA.c
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h main.c
  group CMSIS
    ../Library/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ../Library/CMSIS/DeviceSupport/: system_stm32f10x.c system_stm32f10x.h stm32f10x.h
